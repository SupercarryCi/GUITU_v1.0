# Keil uVision project GUITU_v1.0.uvprojx, settings and files
target GUITU_v1.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: GUITU_v1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Core/App;../Core/Task;../Core/PeripheralDriver;../Core/Algorithm Component;../Core/PeripheralDriver/sx126x_driver
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c spi.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App
    ../Core/App/: app_config.h app_event.h app_msg.h app_rtos.c app_rtos.h app_state.c app_state.h
  group Task
    ../Core/Task/: task_gyro.c task_gyro.h task_adc.c task_adc.h task_control.c task_control.h task_debug.c task_debug.h task_lora.c task_lora.h task_return.c task_return.h task_spo2.c task_spo2.h task_ui.c task_ui.h task_ins_pdr.c task_ins_pdr.h
  group PeripheralDriver
    ../Core/PeripheralDriver/: wit_imu.c wit_imu.h e22_lora_port.c e22_lora_port.h e22_lora_stm32_hal_port.c e22_lora_stm32_hal_port.h e22_lora_tx.c e22_lora_tx.h gtm1000_tag.c gtm1000_tag.h ili9488.c ili9488.h xpt2046.c xpt2046.h tft_port_stm32_hal.c tft_port_stm32_hal.h
    ../compass_icon_c/: compass_icons.c
  group A_Com
    ../Core/Algorithm Component/: pedestrian_frame_transform.c pedestrian_frame_transform.h pedestrian_inertial_nav.c pedestrian_inertial_nav.h pdr_ci.c pdr_ci.h dijkstra.c dijkstra.h
  group e22
    ../Core/PeripheralDriver/sx126x_driver/: lr_fhss_v1_base_types.h sx126x.c sx126x.h sx126x_driver_version.c sx126x_driver_version.h sx126x_hal.h sx126x_lr_fhss.c sx126x_lr_fhss.h sx126x_regs.h lr_fhss_mac.c lr_fhss_mac.h
software components: CMSIS:CORE 4.3.0
